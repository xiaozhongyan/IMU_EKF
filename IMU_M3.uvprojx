# Keil uVision project IMU_M3.uvprojx, settings and files
target imu_m3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103TB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IMU_M3
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: .\drive;.\SYSTEM;.\USER;.\algrithm;.\Math
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: main.c
  group algrithm
    ./algrithm/: IMU_EKF.c
  group math
    ./Math/: FastMath.c Matrix.c Quaternion.c
  group drive
    ./drive/: led.c mpu9250.c usart.c EpRomData.c timer.c IOI2C.c
  group SYSTEM
    ./SYSTEM/: delay.c
software components: CMSIS:CORE 5.1.1, CMSIS:DSP 1.5.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StartupConfig 8.16.0
